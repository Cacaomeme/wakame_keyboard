# Repository Cacaomeme/wakame_keyboard

## KiCad design wakame_keyboard.kicad_pcb

Parts:
R1, R2: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm
U1: Esc; KS-20_1u
U2: 半角/全角; KS-20_1u
U3: L_Ctrl; KS-20_1.25u
U4: Tab; KS-20_1.5u
U5: CapsLock; KS-20_1.75u
U6: L_Shift; KS-20_2.25u
U7: 1; KS-20_1u
U8: L_Win; KS-20_1u
U9: F1; KS-20_1u
U10: Q; KS-20_1u
U11: A; KS-20_1u
U12: 2; KS-20_1u
U13, U14, U15, U16, U17, U18, U57, U63, U70, U73, U81, U93, U96, U97, U98, U99, U100, U101, U102, U104, U105, U106, U107, U108, U109, U110, U111, U112, U113, U115, U116, U117, U118, U119, U120, U121, U122, U123, U125, U126, U127, U128, U129, U130, U131, U132, U133, U134, U135, U137, U138, U139, U140, U141, U142, U143, U144, U145, U146, U148, U149, U150, U151, U152, U153, U154, U155, U156, U157, U158, U160, U161, U162, U163, U164, U165, U166, U167, U168, U169, U170, U171: AH49FNTR-G1; SOT-23
U19: Z; KS-20_1u
U20: L_Alt; KS-20_1.25u
U21: F2; KS-20_1u
U22: W; KS-20_1u
U23: S; KS-20_1u
U24: 3; KS-20_1u
U25: X; KS-20_1u
U26: F3; KS-20_1u
U27: E; KS-20_1u
U28: 無変換; KS-20_1u
U29: D; KS-20_1u
U30: 4; KS-20_1u
U31: C; KS-20_1u
U32: F4; KS-20_1u
U33: R; KS-20_1u
U34: F; KS-20_1u
U35: 5; KS-20_1u
U36: L_Space; KS-20_2.25u
U37: V; KS-20_1u
U38: F5; KS-20_1u
U39: T; KS-20_1u
U40: G; KS-20_1u
U41: 6; KS-20_1u
U42: B; KS-20_1u
U43: F6; KS-20_1u
U44: Y; KS-20_1u
U45: H; KS-20_1u
U46: 7; KS-20_1u
U47: N; KS-20_1u
U48: R_Space; KS-20_2.25u
U49: F7; KS-20_1u
U50: U; KS-20_1u
U51: J; KS-20_1u
U52: 8; KS-20_1u
U53: M; KS-20_1u
U54: F8; KS-20_1u
U55: I; KS-20_1u
U56: K; KS-20_1u
U58: 9; KS-20_1u
U59: 変換; KS-20_1.25u
U60: ,; KS-20_1u
U61: F9; KS-20_1u
U62: O; KS-20_1u
U64: L; KS-20_1u
U65: 0; KS-20_1u
U66: .; KS-20_1u
U67: かな; KS-20_1u
U68: F10; KS-20_1u
U69: P; KS-20_1u
U71: ;; KS-20_1u
U72: -; KS-20_1u
U74: /; KS-20_1u
U75: R_Alt; KS-20_1u
U76: F11; KS-20_1u
U77: @; KS-20_1u
U78: :; KS-20_1u
U79: STM32G431K8Tx; LQFP-32_7x7mm_P0.8mm
U80: ^; KS-20_1u
U82: \; KS-20_1u
U83: F12; KS-20_1u
U84: [; KS-20_1u
U85: ←; KS-20_1u
U86: ]; KS-20_1u
U87: ¥; KS-20_1u
U88: ↑; KS-20_1u
U89: ↓; KS-20_1u
U90: Delete; KS-20_1u
U91: BackSpace; KS-20_1u
U92: Enter; KS-20_2u
U94: 自由; KS-20_1u
U95: →; KS-20_1u
U103, U114, U124, U136, U147, U159: CD74HC4067SM; SSOP-24_5.3x8.2mm_P0.65mm

Connections:
0: U147.5 (I4), U148.2 (OUT)
1: U57.2 (OUT), U103.20 (I11)
2: U96.2 (OUT), U103.22 (I9)
3: U102.2 (OUT), U114.17 (I14)
4: U109.2 (OUT), U114.20 (I11)
5: U114.23 (I8), U116.2 (OUT)
6: U121.2 (OUT), U124.19 (I12)
7: U124.23 (I8), U128.2 (OUT)
8: U134.2 (OUT), U159.7 (I2)
9: U141.2 (OUT), U147.3 (I6)
+3V3: R1.2, U13.1 (VCC), U14.1 (VCC), U15.1 (VCC), U16.1 (VCC), U17.1 (VCC), U18.1 (VCC), U57.1 (VCC), U63.1 (VCC), U70.1 (VCC), U73.1 (VCC), U79.1 (VDD), U79.15 (VDDA), U79.17 (VDD), U81.1 (VCC), U93.1 (VCC), U96.1 (VCC), U97.1 (VCC), U98.1 (VCC), U99.1 (VCC), U100.1 (VCC), U101.1 (VCC), U102.1 (VCC), U103.24 (VCC), U104.1 (VCC), U105.1 (VCC), U106.1 (VCC), U107.1 (VCC), U108.1 (VCC), U109.1 (VCC), U110.1 (VCC), U111.1 (VCC), U112.1 (VCC), U113.1 (VCC), U114.24 (VCC), U115.1 (VCC), U116.1 (VCC), U117.1 (VCC), U118.1 (VCC), U119.1 (VCC), U120.1 (VCC), U121.1 (VCC), U122.1 (VCC), U123.1 (VCC), U124.24 (VCC), U125.1 (VCC), U126.1 (VCC), U127.1 (VCC), U128.1 (VCC), U129.1 (VCC), U130.1 (VCC), U131.1 (VCC), U132.1 (VCC), U133.1 (VCC), U134.1 (VCC), U135.1 (VCC), U136.24 (VCC), U137.1 (VCC), U138.1 (VCC), U139.1 (VCC), U140.1 (VCC), U141.1 (VCC), U142.1 (VCC), U143.1 (VCC), U144.1 (VCC), U145.1 (VCC), U146.1 (VCC), U147.24 (VCC), U148.1 (VCC), U149.1 (VCC), U150.1 (VCC), U151.1 (VCC), U152.1 (VCC), U153.1 (VCC), U154.1 (VCC), U155.1 (VCC), U156.1 (VCC), U157.1 (VCC), U158.1 (VCC), U159.24 (VCC)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; also elsewhere on the board
,: U139.2 (OUT), U147.22 (I9)
-: U147.7 (I2), U153.2 (OUT)
.: U145.2 (OUT), U147.19 (I12)
:: U136.23 (I8), U155.2 (OUT)
;: U147.16 (I15), U150.2 (OUT)
@: U147.9 (I0), U154.2 (OUT)
A: U73.2 (OUT), U103.5 (I4)
ADC1_1: U79.5 (PA0), U147.1 (COM)
ADC1_2: U79.6 (PA1), U136.1 (COM)
ADC1_15: U79.13 (PB0), U103.1 (COM)
ADC2_3: U79.11 (PA6), U124.1 (COM)
ADC2_4: U79.12 (PA7), U114.1 (COM)
ADC2_10: U79.3 (PF1), U159.1 (COM)
B: U120.2 (OUT), U124.6 (I3)
BackSpace: U136.8 (I1), U170.2 (OUT)
C: U107.2 (OUT), U114.6 (I3)
CapsLock: U16.2 (OUT), U103.9 (I0)
D: U105.2 (OUT), U114.9 (I0)
Del: U136.7 (I2), U171.2 (OUT)
E: U104.2 (OUT), U114.16 (I15)
Enter: U136.9 (I0), U167.2 (OUT)
Esc: U13.2 (OUT), U103.18 (I13)
F: U111.2 (OUT), U114.4 (I5)
F1: U81.2 (OUT), U103.21 (I10)
F2: U99.2 (OUT), U114.18 (I13)
F3: U106.2 (OUT), U114.21 (I10)
F4: U112.2 (OUT), U114.22 (I9)
F5: U119.2 (OUT), U124.17 (I14)
F6: U124.21 (I10), U125.2 (OUT)
F7: U131.2 (OUT), U159.6 (I3)
F8: U138.2 (OUT), U159.8 (I1)
F9: U144.2 (OUT), U147.4 (I5)
F10: U147.6 (I3), U151.2 (OUT)
F11: U136.2 (I7), U156.2 (OUT)
F12: U136.5 (I4), U163.2 (OUT)
G: U118.2 (OUT), U124.9 (I0)
GND: R2.1, SW1.2, U13.3 (GND), U14.3 (GND), U15.3 (GND), U16.3 (GND), U17.3 (GND), U18.3 (GND), U57.3 (GND), U63.3 (GND), U70.3 (GND), U73.3 (GND), U79.14 (VSSA), U79.16 (VSS), U79.32 (VSS), U81.3 (GND), U93.3 (GND), U96.3 (GND), U97.3 (GND), U98.3 (GND), U99.3 (GND), U100.3 (GND), U101.3 (GND), U102.3 (GND), U103.12 (GND), U103.15 (~E), U104.3 (GND), U105.3 (GND), U106.3 (GND), U107.3 (GND), U108.3 (GND), U109.3 (GND), U110.3 (GND), U111.3 (GND), U112.3 (GND), U113.3 (GND), U114.12 (GND), U114.15 (~E), U115.3 (GND), U116.3 (GND), U117.3 (GND), U118.3 (GND), U119.3 (GND), U120.3 (GND), U121.3 (GND), U122.3 (GND), U123.3 (GND), U124.12 (GND), U124.15 (~E), U125.3 (GND), U126.3 (GND), U127.3 (GND), U128.3 (GND), U129.3 (GND), U130.3 (GND), U131.3 (GND), U132.3 (GND), U133.3 (GND), U134.3 (GND), U135.3 (GND), U136.12 (GND), U136.15 (~E), U137.3 (GND), U138.3 (GND), U139.3 (GND), U140.3 (GND), U141.3 (GND), U142.3 (GND), U143.3 (GND), U144.3 (GND), U145.3 (GND), U146.3 (GND), U147.12 (GND), U147.15 (~E), U148.3 (GND), U149.3 (GND), U150.3 (GND), U151.3 (GND), U152.3 (GND), U153.3 (GND)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; also elsewhere on the board
H: U123.2 (OUT), U124.2 (I7)
I: U135.2 (OUT), U159.9 (I0)
J: U130.2 (OUT), U159.20 (I11)
K: U137.2 (OUT), U159.16 (I15)
L: U143.2 (OUT), U147.23 (I8)
LED_PWM: U79.9 (PA4); also elsewhere on the board
L_Alt: U100.2 (OUT), U103.4 (I5)
L_Ctrl: U18.2 (OUT), U103.7 (I2)
L_Shift: U17.2 (OUT), U103.8 (I1)
L_Space: U114.5 (I4), U115.2 (OUT)
L_Win: U70.2 (OUT), U103.6 (I3)
M: U132.2 (OUT), U159.17 (I14)
N: U127.2 (OUT), U159.19 (I12)
unnamed: R2.2, U79.31 (PB8)
O: U142.2 (OUT), U147.2 (I7)
P: U147.8 (I1), U149.2 (OUT)
Q: U63.2 (OUT), U103.19 (I12)
R: U110.2 (OUT), U114.19 (I12)
RESET: R1.1, SW1.1, U79.4 (PG10); also elsewhere on the board
R_Alt: U146.2 (OUT), U147.18 (I13)
R_Space: U126.2 (OUT), U159.18 (I13)
S: U98.2 (OUT), U103.2 (I7)
SELECT_0: U79.27 (PB4), U103.10 (S0), U114.10 (S0), U124.10 (S0), U136.10 (S0), U147.10 (S0), U159.10 (S0)
SELECT_1: U79.28 (PB5), U103.11 (S1), U114.11 (S1), U124.11 (S1), U136.11 (S1), U147.11 (S1), U159.11 (S1)
SELECT_2: U79.29 (PB6), U103.14 (S2), U114.14 (S2), U124.14 (S2), U136.14 (S2), U147.14 (S2), U159.14 (S2)
SELECT_3: U79.30 (PB7), U103.13 (S3), U114.13 (S3), U124.13 (S3), U136.13 (S3), U147.13 (S3), U159.13 (S3)
SWCLK: U79.24 (PA14); also elsewhere on the board
SWDIO: U79.23 (PA13); also elsewhere on the board
T: U117.2 (OUT), U124.16 (I15)
Tab: U15.2 (OUT), U103.16 (I15)
U: U129.2 (OUT), U159.4 (I5)
UART_RX: U79.8 (PA3); also elsewhere on the board
UART_TX: U79.7 (PA2); also elsewhere on the board
USB_DM: U79.21 (PA11); also elsewhere on the board
USB_DP: U79.22 (PA12); also elsewhere on the board
V: U113.2 (OUT), U114.3 (I6)
W: U97.2 (OUT), U103.23 (I8)
X: U101.2 (OUT), U114.8 (I1)
Y: U122.2 (OUT), U124.22 (I9)
Z: U93.2 (OUT), U103.3 (I6)
[: U136.4 (I5), U161.2 (OUT)
\: U136.22 (I9), U157.2 (OUT)
]: U136.18 (I13), U162.2 (OUT)
^: U136.3 (I6), U160.2 (OUT)
free: U136.16 (I15), U168.2 (OUT)
hankaku: U14.2 (OUT), U103.17 (I14)
henkan: U133.2 (OUT), U147.21 (I10)
kana: U140.2 (OUT), U147.20 (I11)
muhenkan: U108.2 (OUT), U114.7 (I2)
/: U147.17 (I14), U152.2 (OUT)
¥: U136.6 (I3), U166.2 (OUT)
←: U136.21 (I10), U158.2 (OUT)
↑: U136.19 (I12), U164.2 (OUT)
→: U136.17 (I14), U169.2 (OUT)
↓: U136.20 (I11), U165.2 (OUT)

Notes on the sheet:
無変換
L_Alt
BackSpace
半角/全角
L_win
R_Alt
R_Space
L_Space
LED
L_Ctrl
L_Shift
Tab
F12
CapsLock
F11
F10
Power
Del
Enter
Esc

Parts:
C1, C2, C3: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 0.01u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 0.47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 25v22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D83, D84: 1N4148; D_SOD-123
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Horizontal
R86, R87: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R88: 1.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U172: LM1117GS-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C2.1, C4.1, C5.1, C6.1, D83.2 (A), D84.1 (K), J2.1, R88.2, U172.2 (VO); also elsewhere on the board
+5V: C1.1, C3.1, D83.1 (K), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.8, U172.3 (VI)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D84.2 (A), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.5, J2.12, R86.2, R87.2, U172.1 (GND); also elsewhere on the board
MCO_IN: J2.10
unnamed: J1.A5 (CC1), R86.1
unnamed: J1.B5 (CC2), R87.1
RESET: J2.9; also elsewhere on the board
SWCLK: J2.3; also elsewhere on the board
SWDIO: J2.7; also elsewhere on the board
UART_RX: J2.6; also elsewhere on the board
UART_TX: J2.4; also elsewhere on the board
USB_DM: J1.A7 (D-), J1.B7 (D-); also elsewhere on the board
USB_DP: J1.A6 (D+), J1.B6 (D+), R88.1; also elsewhere on the board

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Q1: BSS138; SOT-23
R3, R4, R5, R6, R7, R8, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+3V3: R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2, R43.2, R44.2, R45.2, R46.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, R67.2, R68.2, R69.2, R70.2, R71.2, R72.2, R73.2, R74.2, R75.2, R76.2, R77.2, R78.2, R79.2, R80.2, R81.2, R82.2, R83.2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; also elsewhere on the board
COM_FET: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), D71.1 (K), D72.1 (K), D73.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), D77.1 (K), D78.1 (K), D79.1 (K), D80.1 (K)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
GND: Q1.2 (S), R9.1; also elsewhere on the board
LED_PWM: Q1.1 (G), R9.2; also elsewhere on the board
unnamed: D1.2 (A), R3.1
unnamed: D2.2 (A), R4.1
unnamed: D3.2 (A), R5.1
unnamed: D4.2 (A), R6.1
unnamed: D5.2 (A), R7.1
unnamed: D6.2 (A), R8.1
unnamed: D7.2 (A), R10.1
unnamed: D8.2 (A), R11.1
unnamed: D9.2 (A), R12.1
unnamed: D10.2 (A), R13.1
unnamed: D11.2 (A), R14.1
unnamed: D12.2 (A), R15.1
unnamed: D13.2 (A), R16.1
unnamed: D14.2 (A), R17.1
unnamed: D15.2 (A), R18.1
unnamed: D16.2 (A), R19.1
unnamed: D17.2 (A), R20.1
unnamed: D18.2 (A), R21.1
unnamed: D19.2 (A), R22.1
unnamed: D20.2 (A), R23.1
unnamed: D21.2 (A), R24.1
unnamed: D22.2 (A), R25.1
unnamed: D23.2 (A), R26.1
unnamed: D24.2 (A), R27.1
unnamed: D25.2 (A), R28.1
unnamed: D26.2 (A), R29.1
unnamed: D27.2 (A), R30.1
unnamed: D28.2 (A), R31.1
unnamed: D29.2 (A), R32.1
unnamed: D30.2 (A), R33.1
unnamed: D31.2 (A), R34.1
unnamed: D32.2 (A), R35.1
unnamed: D33.2 (A), R36.1
unnamed: D34.2 (A), R37.1
unnamed: D35.2 (A), R38.1
unnamed: D36.2 (A), R39.1
unnamed: D37.2 (A), R40.1
unnamed: D38.2 (A), R41.1
unnamed: D39.2 (A), R42.1
unnamed: D40.2 (A), R43.1
unnamed: D41.2 (A), R44.1
unnamed: D42.2 (A), R45.1
unnamed: D43.2 (A), R46.1
unnamed: D44.2 (A), R47.1
unnamed: D45.2 (A), R48.1
unnamed: D46.2 (A), R49.1
unnamed: D47.2 (A), R50.1
unnamed: D48.2 (A), R51.1
unnamed: D49.2 (A), R52.1
unnamed: D50.2 (A), R53.1
unnamed: D51.2 (A), R54.1
unnamed: D52.2 (A), R55.1
unnamed: D53.2 (A), R56.1
unnamed: D54.2 (A), R57.1
unnamed: D55.2 (A), R58.1
unnamed: D56.2 (A), R59.1
unnamed: D57.2 (A), R60.1
unnamed: D58.2 (A), R61.1
unnamed: D59.2 (A), R62.1
unnamed: D60.2 (A), R63.1
unnamed: D61.2 (A), R64.1
unnamed: D62.2 (A), R65.1
unnamed: D63.2 (A), R66.1
unnamed: D64.2 (A), R67.1
unnamed: D65.2 (A), R68.1
unnamed: D66.2 (A), R69.1
unnamed: D67.2 (A), R70.1
unnamed: D68.2 (A), R71.1
unnamed: D69.2 (A), R72.1
unnamed: D70.2 (A), R73.1
unnamed: D71.2 (A), R74.1
unnamed: D72.2 (A), R75.1
unnamed: D73.2 (A), R76.1
unnamed: D74.2 (A), R77.1
unnamed: D75.2 (A), R78.1
unnamed: D76.2 (A), R79.1
unnamed: D77.2 (A), R80.1
unnamed: D78.2 (A), R81.1
unnamed: D79.2 (A), R82.1
unnamed: D80.2 (A), R83.1
unnamed: D81.2 (A), R84.1
unnamed: D82.2 (A), R85.1

Board: 2 copper layers, 293.0 x 120.0 mm, 354 parts (22 on the bottom side), 189 nets.

## Commit log

2026-03-13 first
2026-03-13 配置おおむね完了
2026-03-13 change color
2026-03-15 おおむね完成
